# Keil uVision project SWM320_StdPeriph_Driver.uvprojx, settings and files
target Hello3D (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\bsp;.\GuiLite;.\GuiLite\Hello3D;.\GuiLite\Hello3Ddonut
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM320_StdPeriph_Driver/: SWM320_port.c SWM320_gpio.c SWM320_exti.c SWM320_timr.c SWM320_uart.c SWM320_adc.c SWM320_dma.c SWM320_i2c.c SWM320_pwm.c SWM320_can.c SWM320_spi.c SWM320_sdio.c SWM320_lcd.c SWM320_flash.c SWM320_crc.c SWM320_rtc.c SWM320_wdt.c SWM320_norflash.c SWM320_sdram.c SWM320_sram.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group bsp
    ./APP/bsp/: dev_rgblcd.c dev_systick.c dev_uart.c dev_sdio.c dev_gt911.c
  group GuiLite
    ./GuiLite/: GuiLite.h
  group Hello3D
    ./GuiLite/Hello3D/: Hello3D.cpp
  group Hello3Ddonut
    ./GuiLite/Hello3Ddonut/: Consolas_13.cpp Hello3Ddonut.cpp
  group Hello3Dwave
    ./GuiLite/Hello3Dwave/: Hello3Dwave.cpp
  group HelloCircle
    ./GuiLite/HelloCircle/: HelloCircle.cpp
  group HelloLayers
    ./GuiLite/HelloLayers/: Consolas_19.cpp HelloLayers.cpp
  group HelloMario
    ./GuiLite/HelloMario/: background_bmp.cpp frame_00_bmp.cpp frame_01_bmp.cpp frame_02_bmp.cpp frame_03_bmp.cpp frame_04_bmp.cpp frame_05_bmp.cpp frame_06_bmp.cpp frame_07_bmp.cpp frame_08_bmp.cpp frame_09_bmp.cpp frame_10_bmp.cpp frame_11_bmp.cpp frame_12_bmp.cpp frame_13_bmp.cpp jump_bmp.cpp step1_bmp.cpp step2_bmp.cpp step3_bmp.cpp title_bmp.cpp HelloMario.cpp
  group HelloMolecule
    ./GuiLite/HelloMolecule/: HelloMolecule.cpp
  group HelloNets
    ./GuiLite/HelloNets/: HelloNets.cpp
  group HelloNoTouch
    ./GuiLite/HelloNoTouch/: Consolas_28.cpp HelloNoTouch.cpp
  group HelloParticle
    ./GuiLite/HelloParticle/: HelloParticle.cpp Microsoft_YaHei_28.cpp
  group HelloPendulum
    ./GuiLite/HelloPendulum/: Consolas_19.cpp HelloPendulum.cpp
  group HelloStar
    ./GuiLite/HelloStar/: HelloStar.cpp
  group HelloTimer
    ./GuiLite/HelloTimer/: _DengXian_36B.cpp Consolas_19.cpp grass_bmp.cpp humidity_bmp.cpp temperature_bmp.cpp weather_bmp.cpp HelloTimer.cpp
  group HelloWave
    ./GuiLite/HelloWave/: Lucida_Console_27.cpp HelloWave.cpp
target Hello3Ddonut (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target Hello3Dwave (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloCircle (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\bsp;.\GuiLite;.\GuiLite\Hello3D;.\GuiLite\Hello3Ddonut;.\GuiLite\Hello3Dwave;.\GuiLite\HelloCircle;.\GuiLite\HelloLayers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloLayers (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\bsp;.\GuiLite;.\GuiLite\Hello3D;.\GuiLite\Hello3Ddonut;.\GuiLite\Hello3Dwave;.\GuiLite\HelloCircle;.\GuiLite\HelloLayers;.\GuiLite\HelloMario;.\GuiLite\HelloMolecule
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloMario (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloMolecule (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\bsp;.\GuiLite;.\GuiLite\Hello3D;.\GuiLite\Hello3Ddonut;.\GuiLite\Hello3Dwave;.\GuiLite\HelloCircle;.\GuiLite\HelloLayers;.\GuiLite\HelloNets
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloNets (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\bsp;.\GuiLite;.\GuiLite\Hello3D;.\GuiLite\Hello3Ddonut;.\GuiLite\Hello3Dwave;.\GuiLite\HelloCircle;.\GuiLite\HelloLayers;.\GuiLite\HelloMario;.\GuiLite\HelloMolecule;.\GuiLite\HelloNets;.\GuiLite\HelloNoTouch
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloNoTouch (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloParticle (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloPendulum (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloStar (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloTimer (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
target HelloWave (6150000::V6.15::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.0
  cpu: as above
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\out\SWM320_stdperiph_lib.sct
